# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Fire_FreeRTOS
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\freertos\Source\include;..\freertos\Source\portable\RVDS\ARM_CM3;..\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac5.sct
  group user
    ../User/: main.c
  group FreeRTOS/Source
    ../freertos/Source/: list.c task.c
    ../freertos/Source/include/: list.h portmacro.h FreeRTOSConfig.h FreeRTOS.h portable.h projdefs.h task.h
  group doc
    ./: readm.txt
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.3
